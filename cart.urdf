Commit message: update

File: cart.urdf (robot description, URDF)
Before this commit: robot cart_robot, 1 links, 0 joints
Links:
- link cart_link: geometry collision box size=0.4 0.2 0.1; visual box size=0.4 0.2 0.1
